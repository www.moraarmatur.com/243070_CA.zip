Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2x3 Coordination View
File name: D:\Users\Jonas\Documents\Cadfocus\Ostnor\Projekt\20150210_CAD-objekt-Ove\Arbetsmapp\MA\243070_CA\AutoCAD Architecture\243070_CA.ifc
Time: 2015-03-09T08:59:47
Author: - -
Organization: Mora Armatur
Written by: Eurostep IFC Toolbox - 1.0
Made in: AutoCAD Architecture 2009 Build 5.7.68.0

# IfcProject, 243070_CA
LongName: 243070_CA
PSET_ACA_DISPLAY_SET - ACA_DISPLAY_CONFIG_ON_EXPORT: 02 - Normal detaljering; ACA_DISPLAY_SET_ON_EXPORT: 3D Normal

# IfcBuilding, 243070_CA
ElevationOfRefHeight: 0 mm; ElevationOfTerrain: 0 mm

# IfcBuildingElementProxy: 243070.CA, BUILDINGELEMENTPROXY(1)
In: 243070_CA
Description: Mora Cera B5 Basin Mixer w push down waste, chrome
